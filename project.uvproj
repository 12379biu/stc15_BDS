# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Inc
  asm include: .\Inc
  group Src
    ./Src/: bpc.c Delay.c DS1302.c Key.c KeyTime.c main.c oled.c Timer0.c
  group Inc
    ./Inc/: bpc.h Delay.h DS1302.h Key.h KeyTime.h main.h oled.h OLED_Font.h Timer0.h
